# Keil uVision project DoubleSPItest.uvprojx, settings and files
target Targerts1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\IO;..\HARDWARE\ModBus;..\HARDWARE\servo;..\HARDWARE\includes;..\SYSTEM\TIMER;..\HARDWARE\mtmuart;..\SYSTEM\WDG;..\SYSTEM\SPI;..\HARDWARE\DAC;..\HARDWARE\LED;..\RUN_STEP\AdjOverview;..\RUN_STEP\PowerUp;..\RUN_STEP\ResOverview;..\RUN_STEP\RunOverview;..\HARDWARE\RS485;..\HARDWARE\ADC;..\HARDWARE\PAC_LIB;..\HARDWARE\test;..\SYSTEM\Global;..\SYSTEM\modbus\ascii;..\SYSTEM\modbus\functions;..\SYSTEM\modbus\include;..\SYSTEM\modbus\port;..\SYSTEM\modbus\rtu;..\SYSTEM\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c GAME.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/WDG/: wdg.c
    ../SYSTEM/SPI/: spi.c
    ../SYSTEM/Global/: global.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IO/: io.c
    ../HARDWARE/includes/: includes.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/test/: test.c
  group Modbus
    ../SYSTEM/modbus/ascii/: mbascii.c
    ../SYSTEM/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../SYSTEM/modbus/rtu/: mbcrc.c mbrtu.c
    ../SYSTEM/modbus/tcp/: mbtcp.c
    ../SYSTEM/modbus/: mb.c
  group ModbusPort
    ../SYSTEM/modbus/port/: portevent.c portserial.c porttimer.c mbreg.c
